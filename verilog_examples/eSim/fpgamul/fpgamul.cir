* /home/sumanto/eSim-Workspace/fpgamul/fpgamul.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Mon Oct 11 17:06:51 2021

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U4  clk reset Net-_U3-Pad1_ Net-_U3-Pad2_ adc_bridge_2
v2  reset GND pulse
v1  clk GND pulse
U1  clk plot_v1
U2  reset plot_v1
U11  passed plot_v1
U12  failed plot_v1
U6  cyc GND GND GND GND GND GND GND Net-_U3-Pad3_ Net-_U3-Pad4_ Net-_U3-Pad5_ Net-_U3-Pad6_ Net-_U3-Pad7_ Net-_U3-Pad8_ Net-_U3-Pad9_ Net-_U3-Pad10_ adc_bridge_8
U9  GND GND GND GND GND GND GND GND Net-_U3-Pad27_ Net-_U3-Pad28_ Net-_U3-Pad29_ Net-_U3-Pad30_ Net-_U3-Pad31_ Net-_U3-Pad32_ Net-_U3-Pad33_ Net-_U3-Pad34_ adc_bridge_8
U8  GND GND GND GND GND GND GND GND Net-_U3-Pad19_ Net-_U3-Pad20_ Net-_U3-Pad21_ Net-_U3-Pad22_ Net-_U3-Pad23_ Net-_U3-Pad24_ Net-_U3-Pad25_ Net-_U3-Pad26_ adc_bridge_8
U7  GND GND GND GND GND GND GND GND Net-_U3-Pad11_ Net-_U3-Pad12_ Net-_U3-Pad13_ Net-_U3-Pad14_ Net-_U3-Pad15_ Net-_U3-Pad16_ Net-_U3-Pad17_ Net-_U3-Pad18_ adc_bridge_8
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ passed failed dac_bridge_2
U3  Net-_U3-Pad1_ Net-_U3-Pad2_ Net-_U3-Pad3_ Net-_U3-Pad4_ Net-_U3-Pad5_ Net-_U3-Pad6_ Net-_U3-Pad7_ Net-_U3-Pad8_ Net-_U3-Pad9_ Net-_U3-Pad10_ Net-_U3-Pad11_ Net-_U3-Pad12_ Net-_U3-Pad13_ Net-_U3-Pad14_ Net-_U3-Pad15_ Net-_U3-Pad16_ Net-_U3-Pad17_ Net-_U3-Pad18_ Net-_U3-Pad19_ Net-_U3-Pad20_ Net-_U3-Pad21_ Net-_U3-Pad22_ Net-_U3-Pad23_ Net-_U3-Pad24_ Net-_U3-Pad25_ Net-_U3-Pad26_ Net-_U3-Pad27_ Net-_U3-Pad28_ Net-_U3-Pad29_ Net-_U3-Pad30_ Net-_U3-Pad31_ Net-_U3-Pad32_ Net-_U3-Pad33_ Net-_U3-Pad34_ Net-_U10-Pad1_ Net-_U10-Pad2_ top1
v3  cyc GND pulse
U5  cyc plot_v1

.end
